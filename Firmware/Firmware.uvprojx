# Keil uVision project Firmware.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Firmware
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c adxl345.h general.h spi.h timer.h general.c timer.c servo.c servo.h logs.c logs.h adxl345.c spi.c uart.c uart.h manchester.c manchester.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
